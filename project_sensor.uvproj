# Keil uVision project project_sensor.uvproj, settings and files
target project_sensor (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: project_sensor +hex
  c flags: Optim=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ./lib/common/Realview/: startup_ADuCM360.s interrupt_rvds.s
  group includes
    ./includes/: config.h cportabl.h includes.h macro.h types.h includes-low.h service.h service.cpp
  group reactor
    ./reactor/: reactor.h channel.h channel.cpp event_loop.h event_loop.cpp poller.h poller.cpp timer_queue.h timer_queue.cpp
  group app
    ./app/: main.cpp protocol.cpp ad.cpp devices.cpp env_datum.cpp pin.cpp commu.cpp storage.cpp modbus.cpp pwm.cpp event.cpp timer.cpp
  group api
    ./api/: utils.h utils.cpp timestamp.h timestamp.cpp
    ./api/log/: log.cpp log_stream.cpp
  group bsp
    ./bsp/hal/: hal.cpp
    ./bsp/driver/: drv_interface.cpp
    ./bsp/driver/pin/: drv_pin.cpp
    ./bsp/driver/ad/: drv_ad.cpp
    ./bsp/: bsp_startup.cpp
    ./bsp/cpu/: cpu_uart.cpp cpu_gpio.cpp cpu_iic.cpp cpu_interrupt.cpp cpu_spi.cpp cpu_tick.cpp
    ./bsp/driver/commu/: drv_commu.cpp
    ./bsp/driver/storage/: drv_storage.cpp
    ./bsp/driver/pwm/: drv_pwm.cpp
    ./bsp/driver/event/: drv_event.cpp
    ./bsp/driver/timer/: drv_timer.cpp
  group lib
    ./lib/common/: WutLib.c AdcLib.c ClkLib.c DacLib.c DioLib.c DmaLib.c FeeLib.c GptLib.c I2cLib.c IexcLib.c IntLib.c PwmLib.c PwrLib.c RstLib.c SpiLib.c UrtLib.c WdtLib.c
    ./lib/: lib.h
  group doc
    ./doc/: dev-record.txt
